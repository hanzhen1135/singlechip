# Keil uVision project 51CodeLib.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51CodeLib +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\28DS18B20LED
  group Source Group 1
    ./: STARTUP.A51 ds18b20.c lcd1602.c uart.c dht11.c main.c
